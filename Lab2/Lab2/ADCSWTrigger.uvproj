# Keil uVision project ADCSWTrigger.uvproj, settings and files
target ADCSWTrigger (ARM-ADS)
  device: TM4C1231C3PM Texas Instruments
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x7FFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: ADCSWTrigger
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --c99
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ./: startup.s ADCSWTrigger.c ADCTestMain.c PLL.c Timer1.c ST7735_Line.c ST7735.c Timer2.c
